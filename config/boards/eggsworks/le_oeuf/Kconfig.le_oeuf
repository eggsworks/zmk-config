## config/boards/eggsworks/le_oeuf/Kconfig.le_oeuf
```kconfig
# SPDX-License-Identifier: Apache-2.0

config BOARD_LE_OEUF
	select SOC_NRF52840_QIAA
```
